# Repository Joyec4679/RocketCup-avionic-board-project (continued)

## KiCad design BigAvionic/Second_layer_MCU/Second_layer_MCU.kicad_pcb (continued)

Board: 4 copper layers, 68.0 x 68.0 mm, 98 parts (24 on the bottom side), 89 nets.

## KiCad design BigAvionic/top layer/top_layer.kicad_pcb

Parts:
3V3: TestPoint; TestPoint_Pad_D1.0mm
C1, C5: 1u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C4, C6, C9: 10u; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C7, C8: 100n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1: GPS_LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D2: RED_LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
GND1: TestPoint; TestPoint_Pad_D1.0mm
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3_DIN965_Pad
J1: Conn_01x08; JST_GH_SM08B-GHS-TB_1x08-1MP_P1.25mm_Horizontal
J2: Conn_Coaxial; U.FL_Hirose_U.FL-R-SMT-1_Vertical
J3: Conn_01x04; JST_GH_SM04B-GHS-TB_1x04-1MP_P1.25mm_Horizontal
R1, R6: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R2: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R3, R4: 2.7k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R5: 22ohm; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
TP1: GPS_BOOT; TestPoint_Pad_D1.0mm
U1: NEO-M9N-00B; SMT_9N-00B_UBL
U2: MMC5983MA; MMC5983MA_MEM

Connections:
+3.3V: 3V3.1, C1.1, C5.1, C6.1, C7.1, C8.1, C9.1, J3.3, J3.4, R2.1, R3.1, R4.1, R6.2, U1.22 (V_BCKP), U1.23 (VCC), U2.2 (VDD), U2.4 (SPI_CS), U2.13 (VDDIO); also elsewhere on the board
GND: C1.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, D1.1 (K), D2.1 (K), GND1.1, J1.3, J1.6, J2.2 (Ext), J3.1, J3.2, U1.10 (GND), U1.12 (GND), U1.13 (GND), U1.24 (GND), U2.9 (GND), U2.11 (GND); also elsewhere on the board
I2C1_SCL: J1.5, R3.2, U2.1 (SCL/SPI_SCK)
I2C1_SDA: J1.4, R4.2, U2.16 (SDA/SPI_SDI)
INT_Magn: J1.7, U2.15 (INT)
unnamed: D1.2 (A), R1.1
unnamed: D2.2 (A), R6.1
unnamed: J2.1 (In), U1.11 (RF_IN)
unnamed: R5.2, U1.21 (RXD_/_SPI_MOSI)
unnamed: TP1.1, U1.1 (SAFEBOOT_N)
unnamed: R1.2, U1.3 (TIMEPULSE)
unnamed: C4.1, U2.10 (CAP)
RST_GPS: J1.8, R2.2, U1.8 (RESET_N)
UART6_RX: J1.2, U1.20 (TXD_/_SPI_MISO)
UART6_TX: J1.1, R5.1

Notes on the sheet:
testpoint/LED
Magnetometer
this wire would be long
GPS

Board: 4 copper layers, 68.0 x 68.0 mm, 28 parts (5 on the bottom side), 15 nets.

Other parts of the board:
D3: TVS; D_SMA

Their connections:
+3.3V: D3.2 (A2); also elsewhere on the board
GND: D3.1 (A1); also elsewhere on the board

## KiCad design Deployment board/Deployment board.kicad_pcb

Parts:
2s+1, 3s+1: TestPoint; TestPoint_THTPad_D1.5mm_Drill0.7mm
C1, C2, C5, C6: 1000u; CP_Elec_10x14.3
C3, C4: 100n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C7, C8: 10uF 3.979mOhm; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C9: 47uF 2.674mOhm Qty=3; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D2, D4: D_Schottky; D_SMA-SMB_Universal_Handsoldering
D5: TVS; D_SMA-SMB_Universal_Handsoldering
D6, D7: Indicater; LED_1206_3216Metric_Pad1.42x1.75mm_HandSolder
D8, D9, D10, D11: D_Schottky; D_SOD-323_HandSoldering
F1: Fuse(>15A); Fuse_1206_3216Metric_Pad1.42x1.75mm_HandSolder
GND1: TestPoint; TestPoint_THTPad_D1.5mm_Drill0.7mm
H1, H2, H3, H4: MountingHole; MountingHole_2.2mm_M2
J1, J2: Conn_01x02; JST_EH_B2B-EH-A_1x02_P2.50mm_Vertical
J3: Conn_01x02; Molex_Micro-Fit_3.0_43650-0221_1x02_P3.00mm_Vertical
J4, J5: Conn_01x04; JST_GH_BM04B-GHS-TBT_1x04-1MP_P1.25mm_Vertical
J6, J7: Conn_01x02; JST_GH_BM02B-GHS-TBT_1x02-1MP_P1.25mm_Vertical
M1, M2: Motor_Servo; PinHeader_1x03_P2.54mm_Vertical
Q1, Q2: IRLR7843; TO-252-2
Q3: FDD4141; SOT-23
R1, R4: 100ohm; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R2, R3, R5, R7: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R9: 100k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R10, R11: 3.3k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R12: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R13: 866k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R14: 6.81k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R15: 34.8k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U1: TPSM84824MOLR; MOL0024A

Connections:
2s+: 2s+1.1, C1.1, C6.1, C9.1, M1.2 (+), M2.2 (+), R11.2, R12.2, U1.1 (VOUT), U1.8 (VOUT), U1.V
2sServo1: D9.1 (K), J7.2, M1.1 (PWM), R2.1
2sServo2: D8.1 (K), J7.1, M2.1 (PWM), R7.1
3s+: 3s+1.1, C2.1, C3.2, C4.2, C5.1, C7.1, C8.1, D2.1 (K), D4.1 (K), J1.1, J2.1, Q3.2 (S), R10.2, U1.11 (VIN), U1.22 (VIN), U1.V
3sMotor1: D11.1 (K), J6.2, R4.2
3sMotor2: D10.1 (K), J6.1, R1.2
Backup_AV_FIRE: D11.2 (A), J4.3
Backup_AV_PWM_Servo: D9.2 (A), J4.4
GND: C1.2, C2.2, C5.2, C6.2, C7.2, C8.2, C9.2, D5.1 (A1), D6.1 (K), D7.1 (K), GND1.1, J3.2, J4.1, J4.2, J5.1, J5.2, M1.3 (-), M2.3 (-), Q1.3 (S), Q2.3 (S), R2.2, R3.2, R5.2, R7.2, R9.2, R13.1, R14.1, R15.1, U1.3 (AGND), U1.9 (AGND), U1.12 (PGND), U1.13 (PGND), U1.14 (PGND), U1.15 (PGND), U1.18 (PGND), U1.19 (PGND), U1.20 (PGND), U1.21 (PGND), U1.23 (AGND), U1.V
Main_AV_FIRE: D10.2 (A), J5.3
Main_AV_PWM_Servo: D8.2 (A), J5.4
unnamed: C3.1, D2.2 (A), J1.2, Q1.1 (D)
unnamed: C4.1, D4.2 (A), J2.2, Q2.1 (D)
unnamed: D5.2 (A2), F1.2, Q3.3 (D)
unnamed: D6.2 (A), R10.1
unnamed: D7.2 (A), R11.1
unnamed: F1.1, J3.1
unnamed: Q1.2 (G), R1.1, R3.1
unnamed: Q2.2 (G), R4.1, R5.1
unnamed: Q3.1 (G), R9.1
unnamed: R12.1, R13.2, U1.2 (FB)
unnamed: R15.2, U1.24 (RT_CLK)
unnamed: U1.16 (SW), U1.17 (SW)
unnamed: R14.2, U1.5 (TT)

Notes on the sheet:
3sMotor
1k pull down for lower time constant(tau=RC)
Reverse Protection & Remove Before Flight
3s電源輸入
Test point
12V馬達
(for droguo parachute deployment)
(for main parachute deployment)
Connectors
2sBuck
F1保線絲 D5防突波 R6下拉電阻 Q3(PMOS)開關(防反接保護) J6物理開關 BAT+作為整体電源+
D7防馬達斷電突波 C1防雜訊 C2防馬達啟動瞬間掉電壓
Q4(NMOS)作為開關 R3下拉電阻
Indicator
2sServoMotor

Board: 4 copper layers, 57.1 x 54.0 mm, 52 parts (0 on the bottom side), 24 nets.

## Commit log

2026-01-13 First create of ROCKETCUP Sch&PCB project
2026-01-14 README.md
2026-01-14 add lib folder
2026-01-16 Delete RocketCom directory
    An unintended folder
2026-01-16 add git tutorial in README
2026-01-17 not finished smallavionic Joyce
2026-01-19 Ray push 1/19
2026-01-19 Joyce push 1/19
2026-01-22 1/23 complement
2026-01-26 Joyce push 1/26
2026-02-02 slight modification on small AV , start Big AV
2026-02-03 fix autosave problem
2026-03-04 check
2026-03-05 slight modification
2026-03-09 Ray Wanted to try free routing
2026-03-09 One more time
2026-03-12 jpush
2026-03-12 second need freerouting
2026-03-21 Ray say: GroundStation finish PCB lay out
2026-03-21 add sw
2026-03-21 finish deployment pcb
2026-03-21 finish power layer(still need check)
2026-03-23 jcheck SmallAvionic PowerSystem
2026-03-30 j check SmallAvionic
2026-04-16 checkpoint
2026-04-17 add lora files
2026-04-20 add new power layer
2026-04-20 4/20grounglast
2026-04-22 finish lora layer
2026-04-22 new deployment board
2026-04-23 finish deployment board
2026-04-23 finish lora & top
2026-04-23 new small avionic
2026-04-23 change GS MOS
2026-04-25 power layer finished
2026-04-25 4/25 add some debugger
2026-04-25 check lora top power generate garber
2026-04-25 Groung garber
2026-04-26 MCU process
2026-04-26 MCU layer progress 1
2026-04-27 finish all layer
2026-04-27 smallavionic
2026-04-28 deployment board
2026-04-30 edit some in MCU for production
2026-05-02 Rename LOGO-10*12.1.kicad_mod to LOGO-10x12.1.kicad_mod
2026-05-03 version for v1 production
2026-05-05 update step
2026-06-30 avionic bay bodyV12,topV5

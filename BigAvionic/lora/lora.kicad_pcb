# Repository Joyec4679/RocketCup-avionic-board-project (continued)

## KiCad design SmallAvionic/Joyce2/SmallAvionic.kicad_pcb

Parts:
3V1: TestPoint; TestPoint_THTPad_D2.0mm_Drill1.0mm
BU101: FanPinHeader_1x03_P2.54mm_Vertical
BZ1: Active Buzzer; Buzzer_15x7.5RM7.6
Buck_5v1: TestPoint; TestPoint_THTPad_D2.0mm_Drill1.0mm
C1, C31: 10u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2, C3, C4, C6, C8, C11, C13, C18, C24, C26, C27, C28, C29, C30, C33: 100n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C16, C17: 47u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C20, C23, C32, C104: 1u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C21, C22: 22pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C25: 4.7u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C101: 330u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C102: 22u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C103: 2.2u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1: TVS; D_SMA-SMB_Universal_Handsoldering
D2: G_5V; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D3: B_3V3; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D4: G; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D5: R; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D6: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
F1: Fuse; Fuse_1206_3216Metric_Pad1.42x1.75mm_HandSolder
FB1: FerriteBead 120R @ 100M; L_0805_2012Metric_Pad1.05x1.20mm_HandSolder
GND1: TestPoint; TestPoint_THTPad_D2.0mm_Drill1.0mm
H1, H2, H3, H4: MountingHole; MountingHole_2.2mm_M2
J1: Conn_01x02; Molex_Micro-Fit_3.0_43650-0221_1x02_P3.00mm_Vertical
J2: Boot_mode_pin; PinSocket_1x02_P2.00mm_Vertical
J3: Conn_01x04; PinSocket_1x04_P2.00mm_Vertical
J4: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_HCTL_HC-TYPE-C-16P-01A
J5, J8: Conn_01x03; JST_GH_BM03B-GHS-TBT_1x03-1MP_P1.25mm_Vertical
J6: Conn_01x04; JST_EH_B4B-EH-A_1x04_P2.50mm_Vertical
J7: Screw_Terminal_01x01; TerminalBlock_MetzConnect_360271_1x01_Horizontal_ScrewM3.0_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
J9: Conn_01x02; JST_EH_B2B-EH-A_1x02_P2.50mm_Vertical
L101, L102: 1mH; L_0805_2012Metric_Pad1.05x1.20mm_HandSolder
Q1, Q2: TSM3481CX6 RFG; SOT-23
Q3: NMOS; TO-252-2
R1, R2, R20, R21, R22, R26, R27, R29, R30, R32: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R3, R5, R9: 100k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R7: 1M; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R10: 0 ohm; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R13, R14: 22ohm; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R15, R16, R28: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R17: 1.5k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R18, R19: 5.1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R23, R31: 2.7k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R24, R25: 2.2k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R40: 5k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
SW1: SW_Push; SW_Push_1P1T_NO_E-Switch_TL3301NxxxxxG
SW2: USER_Buttom; SW_Push_1P1T_NO_E-Switch_TL3301NxxxxxG
U1: LD1117S33TR_SOT223; SOT-223-3_TabPin2
U2: STM32F103C8Tx; LQFP-48_7x7mm_P0.5mm
U3: LTC4412xS6; TSOT-23-6
U5: MMC5983MA; MMC5983MA_MEM
U6: BMP390; 10LGA_2X2X0p75_BOS
U7: W25Q128JVS; SOIC-8_5.3x5.3mm_P1.27mm
U8: BMI088; Bosch_LGA-16_4.5x3mm_P0.5mm_LayoutBorder7x1y_ClockwisePinNu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
V_BAT+1: TestPoint; TestPoint_THTPad_D2.0mm_Drill1.0mm
Y1: 8Mhz; Crystal_SMD_0603-4Pin_6.0x3.5mm_HandSoldering

Connections:
+3.3V: 3V1.1, C1.1, C2.1, C3.1, C8.1, C11.1, C13.1, C16.1, C17.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, C32.1, FB1.2, J2.1, J3.1, J6.3, R9.1, R16.2, R17.2, R20.2, R21.2, R22.2, R23.1, R26.2, R27.2, R30.1, R31.1, U1.2 (VO), U2.1 (VBAT), U2.24 (VDD), U2.36 (VDD), U2.48 (VDD), U5.2 (VDD), U5.4 (SPI_CS), U5.13 (VDDIO), U6.1 (VDDIO), U6.10 (VDD), U7.8 (VCC), U8.3 (VDD), U8.11 (VDDIO)
+USB_5V: J4.A4 (VBUS), J4.A9 (VBUS), J4.B4 (VBUS), J4.B9 (VBUS), Q2.3 (D), R5.2, U3.6 (SENSE)
BOOT0: J2.2, R2.1, U2.44 (BOOT0)
BOOT1: R1.1, U2.20 (PB2)
BUCK_5V: BU101.3 (VOUT), Buck_5v1.1, C6.1, C102.1, Q2.2 (S), R15.2, U1.3 (VI), U3.1 (VIN)
Battery_Sensing: C33.1, R32.1, R40.2, U2.19 (PB1)
Buzzer: R28.2, U2.22 (PB11)
CSB_Accel: R27.1, U2.14 (PA4), U8.14 (~CSB1)
CSB_Baro: R30.2, U2.18 (PB0), U6.6 (CSB)
CSB_Flash: R26.1, U2.29 (PA8), U7.1 (~CS)
CSB_Gyro: R22.1, U2.13 (PA3), U8.5 (~CSB2)
FIRE: J5.2, U2.45 (PB8)
GND: BU101.2 (GND), C1.2, C2.2, C3.2, C4.2, C6.2, C8.2, C11.2, C13.2, C16.2, C17.2, C18.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C102.2, C104.2, D1.1 (A1), D2.1 (K), D3.1 (K), GND1.1, J1.2, J3.4, J4.A1 (GND), J4.A12 (GND), J4.B1 (GND), J4.B12 (GND), J4.S1 (SHIELD), J5.3, J6.4, J7.1, J8.3, L102.2, Q3.3 (S), R1.2, R2.2, R3.2, R7.2, R18.2, R19.2, R24.1, R25.1, R29.2, R40.1, SW1.1, SW2.1, U1.1 (GND), U2.8 (VSSA), U2.23 (VSS), U2.35 (VSS), U2.47 (VSS), U3.2 (GND), U5.9 (GND), U5.11 (GND), U6.3 (VSS), U6.8 (VSS), U6.9 (VSS), U7.4 (GND), U8.2 (GNDA), U8.4 (GNDA), U8.6 (GNDIO), U8.7 (PS), Y1.2 (G), Y1.4 (G)
HSE_IN: C21.1, U2.5 (PD0), Y1.1
HSE_OUT: R10.1, U2.6 (PD1), Y1.3
I2C1_SCL: J6.1, R23.2, U2.42 (PB6), U5.1 (SCL/SPI_SCK)
I2C1_SDA: J6.2, R31.2, U2.43 (PB7), U5.16 (SDA/SPI_SDI)
INT_Accel1: U2.10 (PA0), U8.16 (INT1)
INT_Accel2: U2.11 (PA1), U8.1 (INT2)
INT_Baro: U2.21 (PB10), U6.7 (INT)
INT_Gyro: U2.12 (PA2), U8.12 (INT3)
INT_Magn: U2.41 (PB5), U5.15 (INT)
LED_SYS: D4.2 (A), U2.2 (PC13)
LED_State: D5.2 (A), U2.3 (PC14)
NRST: C4.1, SW1.2, U2.7 (NRST)
unnamed: BU101.1 (VIN), C104.1, L101.2
unnamed: BZ1.2 (-), D6.2 (A), Q3.1 (D)
unnamed: C22.1, R10.2
unnamed: C101.2, C103.2, L102.1
unnamed: D1.2 (A2), F1.2, J9.2, Q1.3 (D)
unnamed: D2.2 (A), R15.1
unnamed: D3.2 (A), R16.1
unnamed: D4.1 (K), R24.2
unnamed: D5.1 (K), R25.2
unnamed: F1.1, J1.1
unnamed: J4.A5 (CC1), R18.1
unnamed: J4.B5 (CC2), R19.1
unnamed: J4.A6 (D+), J4.B6 (D+), R14.2
unnamed: J4.A7 (D-), J4.B7 (D-), R13.1
unnamed: Q1.1 (G), R3.1
unnamed: Q2.1 (G), U3.5 (GATE)
unnamed: Q3.2 (G), R28.1, R29.1
unnamed: C18.1, C20.1, FB1.1, U2.9 (VDDA)
unnamed: R5.1, R7.1, U3.3 (CTL)
unnamed: C31.1, U5.10 (CAP)
unnamed: R20.1, U7.7 (~HOLD/~RESET/IO_{3})
PWM Servo: J5.1, U2.46 (PB9)
SPI1_MISO: U2.16 (PA6), U6.5 (SDO), U8.10 (SDO2), U8.15 (SDO1)
SPI1_MOSI: U2.17 (PA7), U6.4 (SDI), U8.9 (SDI/SDA)
SPI1_SCK: U2.15 (PA5), U6.2 (SCK), U8.8 (SCK/SCL)
SPI2_MISO: U2.27 (PB14), U7.2 (DO/IO_{1})
SPI2_MOSI: U2.28 (PB15), U7.5 (DI/IO_{0})
SPI2_SCK: U2.26 (PB13), U7.6 (CLK)
SUP_STAT: R9.2, U2.40 (PB4), U3.4 (STAT)
SWCLK: J3.3, U2.37 (PA14)
SWDIO: J3.2, U2.34 (PA13)
USART1_RX: J8.2, U2.31 (PA10)
USART1_TX: J8.1, U2.30 (PA9)
USB_D+: R14.1, R17.1, U2.33 (PA12)
USB_D-: R13.2, U2.32 (PA11)
USER_BT: C30.1, SW2.2, U2.4 (PC15)
V_BAT+: BZ1.1 (+), C101.1, C103.1, D6.1 (K), J9.1, L101.1, Q1.2 (S), R32.2, V_BAT+1.1
WP_Flash: R21.1, U2.25 (PB12), U7.3 (~WP/IO_{2})

Notes on the sheet:
C33濾波
Power
C32濾波
讓大小航電板共地
用USB供電 &防止電池電流倒灌到USB
common ground to Main_AV GND
decoupling
UART communication
V=BAT(8.4)*5/(5+10)=2.8V
Battery monitor
Flash
決定開機後要正常執行or重灌
3.3V是用於open-drain，並非電源輸出
Buck
把5V再轉為3.3V給mcu跟感測器用
Indicator
C4去彈跳電容， 吸收雜訊
clock
Connection to Main_AV
狀態輸出腳位
External reset
C30濾波
IMU
Buttom
PB12 GPIO_OUT
C27在VCC旁邊 C25在3.3V旁
磁珠:抑制高頻雜訊
LDO
SDA、SCL要上拉
maybe a remove before flight?
47uF(tantalum capacitor
C26C29要記得放在VDD、VDDIO旁邊
Serial Wire Debug
C21C22負載電容， 負責與石英晶體共振
buck_5V再接到LDO
Remove Before Flight
CSB上拉
防反向突波
Ignition connector
Boot&Debug

Board: 4 copper layers, 76.8 x 61.5 mm, 99 parts (0 on the bottom side), 63 nets.

## KiCad design GroundStation/GroundStation/GroundStation.kicad_pcb

Parts:
3V3: TestPoint; TestPoint_Pad_2.0x2.0mm
BU101: FanPinHeader_1x03_P2.54mm_Vertical
Buck_5v101: TestPoint; TestPoint_Pad_2.0x2.0mm
C2: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C6, C39: 10u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C7, C8, C9, C10, C21, C23, C40, C43, C45, C66: 100n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C22, C24: 47u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C26: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C27, C28: 22pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C44: 100u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C46, C102: 22u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C77, C104: 1u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C101: 330u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C103: 2.2u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D2: B_3V3; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D3: TVS; D_SOD-123
D4: GPS_LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D101: G_5V; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D102, D104: D_Schottky; D_SMA
F1: Fuse; Fuse_1206_3216Metric
FB1: FerriteBead 120R @ 100M; L_2512_6332Metric
GND101: TestPoint; TestPoint_Pad_2.0x2.0mm
H101, H102, H103: MountingHole; MountingHole_3.2mm_M3
J1: SD_Card_Receptacle; SD_Kyocera_145638109511859+
J3: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
J4: Conn_Coaxial; U.FL_Hirose_U.FL-R-SMT-1_Vertical
J5: Conn_01x02; Molex_Micro-Fit_3.0_43650-0200_1x02_P3.00mm_Horizontal
J101, J102: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
L101, L102: 1mH; L_0805_2012Metric_Pad1.05x1.20mm_HandSolder
P1: USB_C_Plug_USB2.0; USB_C_Receptacle_JAE_DX07S016JA1R1500
Q1: AO3401A; SOT-23
R2_up1, R3, R3_up1, R4, R29, R32, R33: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R16, R17, R26: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R18: 100k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R30, R31: 22ohm; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
SW1: SW_Push; SW_PUSH_6mm_H4.3mm
TP1: GPS_BOOT; TestPoint_Pad_D1.0mm
U1: STM32F103C8Tx; LQFP-48_7x7mm_P0.5mm
U9: NEO-M9N-00B; ublox_NEO
U10: E22-400T30S; e22-400t30s_Package
U11: E80-900M23313S; E80-900M2213S
U101: LD1117S33TR_SOT223; SOT-223-3_TabPin2
V_BAT+101: TestPoint; TestPoint_Pad_2.0x2.0mm
Y1: 8Mhz; Crystal_SMD_5032-4Pin_5.0x3.2mm

Connections:
+3.3V: 3V3.1, C2.1, C6.1, C7.1, C8.1, C9.1, C10.1, C21.1, C22.1, C24.1, C39.1, C40.1, C43.1, C44.1, C45.1, C46.1, J1.4 (VDD), J3.1, J101.1, R2_up1.1, R17.2, R29.1, R32.2, R33.2, U1.1 (VBAT), U1.24 (VDD), U1.36 (VDD), U1.48 (VDD), U9.22 (V_BCKP), U9.23 (VCC), U10.2 (VCC), U11.25 (VCC), U101.2 (VO)
BOOT0: J101.2, R3.1, U1.44 (BOOT0)
BOOT1: R4.1, U1.20 (PB2)
BUCK_5V: BU101.3 (VOUT), Buck_5v101.1, C102.1, D102.2 (A), R16.2
GND: BU101.2 (GND), C2.2, C6.2, C7.2, C8.2, C9.2, C10.2, C21.2, C22.2, C23.2, C24.2, C26.2, C27.2, C28.2, C39.2, C40.2, C43.2, C44.2, C45.2, C46.2, C66.2, C77.2, C102.2, C104.2, D2.1 (K), D3.1 (A1), D4.1 (K), D101.1 (K), GND101.1, J1.3 (VSS), J1.6 (VSS), J1.12 (SHELL1), J1.13 (SHELL2), J3.4, J4.2 (Ext), J5.2, L102.2, P1.A1 (GND), P1.A12 (GND), P1.B1 (GND), P1.B12 (GND), P1.S1 (SHIELD), R3.2, R3_up1.2, R4.2, R18.2, SW1.1, U9.10 (GND), U9.12 (GND), U9.13 (GND), U9.24 (GND), U10.1 (GND), U10.12 (GND), U10.13 (GND), U10.14 (GND), U10.23 (GND), U11.1 (GND), U11.8 (GND), U11.19 (GND), U11.26 (GND), U101.1 (GND), Y1.2 (G), Y1.4 (G); also elsewhere on the board
HSE_IN: C27.1, U1.10 (PA0), Y1.1
HSE_OUT: C28.1, U1.11 (PA1), Y1.3
unnamed: BU101.1 (VIN), C104.1, L101.2
unnamed: C101.2, C103.2, L102.1
unnamed: D2.2 (A), R17.1
unnamed: D3.2 (A2), F1.2, Q1.3 (D)
unnamed: D4.2 (A), R26.1
unnamed: D101.2 (A), R16.1
unnamed: C23.1, D102.1 (K), D104.1 (K), U101.3 (VI)
unnamed: J4.1 (In), U9.11 (RF_IN)
unnamed: F1.1, J5.1
unnamed: P1.A5 (CC), R3_up1.1
unnamed: Q1.1 (G), R18.1
unnamed: C66.1, C77.1, FB1.1, U1.9 (VDDA)
unnamed: TP1.1, U9.1 (SAFEBOOT_N)
unnamed: R26.2, U9.3 (TIMEPULSE)
unnamed: R30.1, U10.5 (RXD)
unnamed: R31.1, U10.4 (TXD)
unnamed: R33.1, U11.21 (LR_NRST)
RESET: C26.1, J102.1, J102.2, SW1.2, U1.7 (NRST); also elsewhere on the board
SPI1_LoRa2_CS: U1.29 (PA8), U11.6 (NSS)
SPI1_LoRa2_MISO: U1.16 (PA6), U11.3 (MISO)
SPI1_LoRa2_MOSI: U1.17 (PA7), U11.4 (MOSI)
SPI1_LoRa2_SCK: U1.15 (PA5), U11.5 (SCK)
SPI2_SDcard_CS: J1.1 (CD/DAT3), R2_up1.2, U1.21 (PB10)
SPI2_SDcard_MISO: J1.7 (DAT0), U1.27 (PB14)
SPI2_SDcard_MOSI: J1.5 (CLK), U1.26 (PB13)
SPI2_SDcard_SCK: J1.2 (CMD), U1.28 (PB15)
SWCLK: J3.3, U1.37 (PA14)
SWDIO: J3.2, U1.34 (PA13)
USART1_GPS_RESET: R29.2, U1.22 (PB11), U9.8 (RESET_N)
USART1_GPS_RX: U1.31 (PA10), U9.20 (TXD_/_SPI_MISO)
USART1_GPS_TX: U1.30 (PA9), U9.21 (RXD_/_SPI_MOSI)
USART2_LoRa1_AUX: U1.14 (PA4), U10.3 (AUX)
USART2_LoRa1_M0: U1.19 (PB1), U10.7 (M0)
USART2_LoRa1_M1: U1.39 (PB3), U10.6 (M1)
USART2_LoRa1_NRST: R32.1, U1.18 (PB0), U10.22 (RESET)
USART2_LoRa1_RX: R31.2, U1.12 (PA2)
USART2_LoRa1_TX: R30.2, U1.13 (PA3)
USB_5V: D104.2 (A), P1.A4 (VBUS), P1.A9 (VBUS), P1.B4 (VBUS), P1.B9 (VBUS)
USB_DP_D+: P1.A6 (D+), U1.33 (PA12)
USB_DX_D-: P1.A7 (D-), U1.32 (PA11)
V_BAT+: C101.1, C103.1, L101.1, Q1.2 (S), V_BAT+101.1

Notes on the sheet:
using ipx in the lora model
LORA 433
External reset
boot mode
LORA 920
HSE crystal
Reverse Protection
Buck
decoupling
LDO
maybe a remove before flight?
Test point
Reserved for active atenna
Power
Serial Wire Debug
MCU的TX跟RX
go out
Indicator

Board: 4 copper layers, 82.2 x 108.3 mm, 71 parts (0 on the bottom side), 48 nets.

Other parts of the board:
REST: SW_Push; SW_PUSH_6mm_H4.3mm

Their connections:
GND: REST.1; also elsewhere on the board
RESET: REST.2; also elsewhere on the board

## KiCad design BigAvionic/power layer_previous/power layer.kicad_pcb

Board: 4 copper layers, 68.0 x 68.0 mm, 56 parts (0 on the bottom side), 22 nets.

Parts:
3V3: TestPoint; TestPoint_Pad_D1.0mm
5V1: TestPoint; TestPoint_Pad_1.0x1.0mm
Buck_5v1: TestPoint; TestPoint_Pad_D1.0mm
C1: 10u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C12: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C13, C14, C15: 4.7u; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C16: 10p; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C17, C18, C19, C22, C24: 47u; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C21, C23, C52: 100n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1: G_5V; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D2: B_3V3; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D3: TVS; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D5: SS24; D_SMA
F1: Fuse; Fuse_0805_2012Metric_Pad1.15x1.40mm_HandSolder
GND1: TestPoint; TestPoint_Pad_1.0x1.0mm
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3_DIN965_Pad
J1, J2, J3, J4: Conn_01x04; JST_GH_SM04B-GHS-TB_1x04-1MP_P1.25mm_Horizontal
J5: Conn_01x02; JST_PH_S2B-PH-K_1x02_P2.00mm_Horizontal
J6: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_HRO_TYPE-C-31-M-12
L1: 6.8u; L_7.3x7.3_H3.5
Q1, Q2: TSM3481CX6 RFG; SOT-23
R1: 390k; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
R2, R3, R18, R19, R21: 100k; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
R6, R7: 5.1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R13: 18k; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
R14: 220k; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
R15: 30k; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
R16, R17: 1k; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
R20: 1M; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
R52: 10k; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
R55: 5k; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
U2: LD1117S33TR_SOT223; SOT-223-3_TabPin2
U3: LTC4412xS6; TSOT-23-6
U4: TPS54538RQFR; VQFN-HR9_RQF_TEX(TPS54538)
V_BAT+1: TestPoint; TestPoint_Pad_D1.0mm

Connections:
5V: 5V1.1, C1.1, C23.1, D5.1 (K), Q2.3 (D), U2.3 (VI), U3.6 (SENSE)
+3.3V: 3V3.1, C21.1, C22.1, C24.1, J2.1, J2.2, J3.1, J3.2, J4.1, J4.2, R3.1, R17.2, R21.1, U2.2 (VO)
+USB_5V: D5.2 (A), J6.A4 (VBUS), J6.A9 (VBUS), J6.B4 (VBUS), J6.B9 (VBUS), R19.2
BUCK_5V: Buck_5v1.1, C16.1, C17.1, C18.1, C19.1, L1.1, Q2.2 (S), R14.1, R16.2, U3.1 (VIN)
Battery_Sensing: C52.1, J1.1, R52.1, R55.2
GND: C1.2, C12.2, C13.2, C14.2, C15.2, C17.2, C18.2, C19.2, C21.2, C22.2, C23.2, C24.2, C52.2, D1.1 (K), D2.1 (K), D3.1 (A1), GND1.1, J1.4, J2.3, J2.4, J3.3, J3.4, J4.3, J4.4, J5.2, J6.A1 (GND), J6.A12 (GND), J6.B1 (GND), J6.B12 (GND), J6.S1 (SHIELD), R2.1, R6.2, R7.2, R13.2, R15.2, R18.2, R20.2, R55.1, U2.1 (GND), U3.2 (GND), U4.4 (GND)
unnamed: D1.2 (A), R16.1
unnamed: D2.2 (A), R17.1
unnamed: D3.2 (A2), F1.2, Q1.3 (D)
unnamed: F1.1, J5.1
unnamed: J6.A5 (CC1), R6.1
unnamed: J6.B5 (CC2), R7.1
unnamed: Q1.1 (G), R18.1
unnamed: Q2.1 (G), U3.5 (GATE)
unnamed: R19.1, R20.1, U3.3 (CTL)
unnamed: R1.1, R2.2, U4.2 (EN)
unnamed: C16.2, R14.2, R15.1, U4.3 (FB)
unnamed: R13.1, U4.7 (MODE)
unnamed: L1.2, U4.8 (SW)
PG_BUCK: J1.3, R3.2, U4.9 (SS/PG)
SUP_STAT: J1.2, R21.2, U3.4 (STAT)
V_BAT+: C12.1, C13.1, C14.1, C15.1, Q1.2 (S), R1.2, R52.2, U4.5 (VIN), U4.6 (VIN), V_BAT+1.1
